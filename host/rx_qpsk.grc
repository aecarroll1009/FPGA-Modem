options:
  parameters:
    author: FPGA SDR Modem
    comment: |-
      Live baseband IQ from the DE1-SoC, straight off the wire.

      Start hps/iq_streamd on the board pointing at this host,
      then run this flowgraph. No throttle: the board's 400 kS/s
      paces the stream.

      The FPGA has no carrier or timing recovery, so a real
      signal shows the constellation rotating; see the README's
      roadmap.
    description: DE1-SoC live IQ viewer
    generate_options: qt_gui
    id: rx_qpsk
    output_language: python
    realtime_scheduling: 'On'
    title: DE1-SoC live IQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Mixer rate. 50000 if iq_streamd ran with --rate decimated.
    value: '400000'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    comment: Must match iq_streamd --port
    label: UDP port
    type: intx
    value: '5000'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: |-
      Raw interleaved int16 pairs: UDP delimits the
      datagrams, so there is no header to strip.
    eof: 'False'
    ipaddr: 0.0.0.0
    port: udp_port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    comment: Scales the 16-bit datapath word to +/-1.0
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: '"Baseband spectrum"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.0'
    comment: |-
      Rotates when the carrier is offset: there is no
      carrier recovery in the chain yet.
    grid: 'True'
    gui_hint: 0,1,1,1
    name: '"Constellation"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I
    label2: Q
    name: '"I and Q against time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
