options:
  parameters:
    author: FPGA SDR Modem
    comment: |-
      Views the baseband IQ captured from the DE1-SoC by
      host/capture_iq.py --format cfloat.

      The FPGA has no carrier or timing recovery, so a real
      signal shows the constellation rotating; see the README's
      roadmap.
    description: DE1-SoC baseband IQ viewer
    generate_options: qt_gui
    id: rx_qpsk
    output_language: python
    title: DE1-SoC baseband IQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'fs_out: 400 kS/s decimated by 8'
    value: '50000'
  states: {}
- name: iq_path
  id: parameter
  parameters:
    comment: Written by host/capture_iq.py --format cfloat
    label: IQ capture file
    type: str
    value: ../build/capture.cf32
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: iq_path
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: '"Baseband spectrum"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.0'
    comment: |-
      Rotates when the carrier is offset: there is no
      carrier recovery in the chain yet.
    grid: 'True'
    gui_hint: 0,1,1,1
    name: '"Constellation"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I
    label2: Q
    name: '"I and Q against time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
